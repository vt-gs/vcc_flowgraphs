<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gmsk_tx_burst_hier2</value></param>
<param><key>author</key><value>Zach Leffke, KJ4QLP</value></param>
<param><key>category</key><value>[VCC Hier Blocks]</value></param>
<param><key>description</key><value>Hierarchical GMSK Transmitter</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GMSK TX Burst tagger</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>24</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_var</value></param>
<param><key>value</key><value>samp_rate / interp * decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>value</key><value>samp_rate_var/baud</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_symb_0</value></param>
<param><key>value</key><value>samps_per_symb * baud</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>comment</key><value>pack bytes for 
GMSK Mod Block</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>samps_per_symb * 8.0 * interp / decim</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
<param><key>minoutbuf</key><value>50000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bt</value></param>
<param><key>label</key><value>BT</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>delay_enable</value></param>
<param><key>label</key><value>Delay Enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>bt</value></param>
<param><key>comment</key><value>expects packed 
byte stream</value></param>
<param><key>samples_per_symbol</key><value>int(samps_per_symb)</value></param>
</block>
<block>
<key>digital_scrambler_bb</key>
<param><key>id</key><value>digital_scrambler_bb_0</value></param>
<param><key>comment</key><value>G3RUH Polynomial
1+x^12+x^17</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x0</value></param>
</block>
<block>
<key>foo_burst_tagger</key>
<param><key>id</key><value>foo_burst_tagger_0</value></param>
<param><key>minoutbuf</key><value>50000</value></param>
<param><key>mult</key><value>int(samps_per_symb * 8.0 * interp / decim)</value></param>
<param><key>tag_name</key><value>pmt.intern("packet_len")</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>ptt_delay</value></param>
<param><key>delay</key><value>bool(delay_enable)</value></param>
<param><key>pad_front</key><value>pad_front</value></param>
<param><key>pad_tail</key><value>pad_tail</value></param>
</block>
<block>
<key>kiss_hdlc_framer</key>
<param><key>id</key><value>kiss_hdlc_framer_0</value></param>
<param><key>comment</key><value>Computes FCS, append
Bit Stuff Frame
Append/Prepend Flags</value></param>
<param><key>postamble_bytes</key><value>64</value></param>
<param><key>preamble_bytes</key><value>64</value></param>
</block>
<block>
<key>kiss_kiss_to_pdu</key>
<param><key>id</key><value>kiss_kiss_to_pdu_0</value></param>
<param><key>comment</key><value>Discard KISS FEND bytes
Escapes Bytes as necessary
Removes KISS CMD Byte</value></param>
<param><key>control_byte</key><value>True</value></param>
</block>
<block>
<key>kiss_nrzi_encode</key>
<param><key>id</key><value>kiss_nrzi_encode_0</value></param>
<param><key>comment</key><value>NRZI Differential
Line Encoding</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pad_front</value></param>
<param><key>label</key><value>Pad Front</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>comment</key><value>AX.25 header is not ASCII printable
Some characters will not print properly</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>ax25</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>comment</key><value>Expects KISS Frames on input
&lt;FEND&gt;&lt;CMD&gt;&lt;DATA&gt;&lt;FEND&gt;
DATA = AX.25 Frame</value></param>
<param><key>label</key><value>kiss/ax25</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pad_tail</value></param>
<param><key>label</key><value>Pad Front</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>pdu_utils_pack_unpack</key>
<param><key>id</key><value>pdu_utils_pack_unpack_0</value></param>
<param><key>bit_order</key><value>pdu_utils.BIT_ORDER_LSB_FIRST</value></param>
<param><key>comment</key><value>pack bytes for 
GMSK Mod Block</value></param>
<param><key>mode</key><value>pdu_utils.MODE_PACK_BYTE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ptt_delay</value></param>
<param><key>label</key><value>PTT Delay</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>upsample to 250k for UHD</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>interp</key><value>interp</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>vcc_burst_extract_fc</key>
<param><key>id</key><value>vcc_burst_extract_fc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag</key><value>"packet_len"</value></param>
<param><key>mult</key><value>samps_per_symb</value></param>
</block>
<block>
<key>vcc_burst_nrzi_encode</key>
<param><key>id</key><value>vcc_burst_nrzi_encode_0</value></param>
<param><key>comment</key><value>NRZI Differential
Line Encoding</value></param>
</block>
<block>
<key>vcc_burst_scramble_bb</key>
<param><key>id</key><value>vcc_burst_scramble_bb_0</value></param>
<param><key>comment</key><value>G3RUH Polynomial
1+x^12+x^17</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>bytes</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0_1</value></param>
<param><key>stream_id</key><value>bytes</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>kiss_kiss_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>foo_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_burst_tagger_0</source_block_id><sink_block_id>foo_packet_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_hdlc_framer_0</source_block_id><sink_block_id>vcc_burst_scramble_bb_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>kiss_kiss_to_pdu_0</source_block_id><sink_block_id>kiss_hdlc_framer_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>kiss_kiss_to_pdu_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pdu_utils_pack_unpack_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>foo_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vcc_burst_nrzi_encode_0</source_block_id><sink_block_id>pdu_utils_pack_unpack_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>vcc_burst_scramble_bb_0</source_block_id><sink_block_id>vcc_burst_nrzi_encode_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0_1</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
