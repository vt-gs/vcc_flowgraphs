<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>burst_detect_es</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>avg_len</value></param>
<param><key>value</key><value>100.0</value></param>
<param><key>gui_hint</key><value>4,4,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>int(samp_rate/2000)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_avg_len</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>baud*samps_per_symb / 2 / nfft-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_dev</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>24</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>loop_bw</value></param>
<param><key>value</key><value>900</value></param>
<param><key>gui_hint</key><value>6,2,1,2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>max_min_freq</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>6,0,1,2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_symbols</value></param>
<param><key>value</key><value>samps_per_symb*300*8 *2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>4,6,1,2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>value</key><value>int((samp_rate/decim*interp)/baud)</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>10</value></param>
<param><key>comment</key><value>automatic gain control</value></param>
<param><key>decay_rate</key><value>1e-1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>65536</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1</value></param>
<param><key>comment</key><value>FSK/GMSK
demodulator</value></param>
<param><key>gain</key><value>(samp_rate/decim*interp)/(2*math.pi*fsk_dev/8.0)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1_0</value></param>
<param><key>comment</key><value>FSK/GMSK
demodulator</value></param>
<param><key>gain</key><value>(samp_rate/decim*interp)/(2*math.pi*fsk_dev/8.0)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-1*offset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>bits</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value>Demod Bits</value></param>
<param><key>style</key><value>dots</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>nfft</value></param>
</block>
<block>
<key>blocks_burst_tagger</key>
<param><key>id</key><value>blocks_burst_tagger_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false_key</key><value>burst</value></param>
<param><key>false_value</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>true_key</key><value>burst</value></param>
<param><key>true_value</key><value>True</value></param>
</block>
<block>
<key>blocks_char_to_short</key>
<param><key>id</key><value>blocks_char_to_short_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vlen</key><value>nfft</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int(avg_len)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/zleffke/captures/lithium_20180327/downlink_data_1.fc32</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>1024*8</value></param>
<param><key>n</key><value>max_symbols*2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>int(avg_len)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/avg_len</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>1</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vlen</key><value>nfft</value></param>
<param><key>length</key><value>fft_avg_len</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/(fft_avg_len)/nfft</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>1</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>samp_rate*interp/decim/nfft</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>-1*samp_rate*interp/decim/(2*math.pi)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1</value></param>
<param><key>const</key><value>-1*samp_rate*interp/decim/(2*math.pi)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vlen</key><value>nfft</value></param>
<param><key>k</key><value>-10*math.log10(nfft)</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_remove</key>
<param><key>id</key><value>blocks_pdu_remove_0</value></param>
<param><key>k</key><value>pmt.intern("es::event_buffer")</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>es::event_length</value></param>
<param><key>minoutbuf</key><value>baud*samps_per_symb</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1</value></param>
<param><key>num_items</key><value>200</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nfft</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>burst_fsk_time_sync</key>
<param><key>id</key><value>burst_fsk_time_sync_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n_offsets</key><value>5</value></param>
<param><key>samp_rate</key><value>samp_rate*interp/decim</value></param>
<param><key>sps</key><value>0</value></param>
<param><key>R</key><value>5</value></param>
</block>
<block>
<key>burst_length_detect</key>
<param><key>id</key><value>burst_length_detect_0</value></param>
</block>
<block>
<key>burst_slicer</key>
<param><key>id</key><value>burst_slicer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>comment</key><value>soft bits to hard bits</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>comment</key><value>Timing Recovery</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.25</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samps_per_symb*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>comment</key><value>G3RUH Polynomial
1+x^12+x^17</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>rolloff</key><value>0.5</value></param>
<param><key>w</key><value>math.pi/loop_bw</value></param>
<param><key>filter_size</key><value>256</value></param>
<param><key>samps_per_sym</key><value>samps_per_symb</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>baud*samps_per_symb / 4</value></param>
<param><key>lookback</key><value>int(avg_len*2)</value></param>
<param><key>guard</key><value>300</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>thresh</key><value>-2</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.blackmanharris(nfft)</value></param>
</block>
<block>
<key>kiss_hdlc_deframer</key>
<param><key>id</key><value>kiss_hdlc_deframer_0</value></param>
<param><key>check_fcs</key><value>True</value></param>
<param><key>comment</key><value>Searches for flags to detect Frame
'unstuffs' tx bit stuffing
checks FCS for bit errors</value></param>
<param><key>max_length</key><value>300</value></param>
</block>
<block>
<key>kiss_nrzi_decode</key>
<param><key>id</key><value>kiss_nrzi_decode_0</value></param>
<param><key>comment</key><value>NRZI Differential
Line Decoding</value></param>
</block>
<block>
<key>kiss_pdu_to_kiss</key>
<param><key>id</key><value>kiss_pdu_to_kiss_0</value></param>
<param><key>comment</key><value>Wraps AX.25 Frame in KISS protocol
&lt;FEND&gt;&lt;CMD&gt;&lt;DATA&gt;&lt;FEND&gt;
Escapes DATA bytes as needed</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>comment</key><value>narrow signal filter</value></param>
<param><key>cutoff_freq</key><value>lpf_cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate / decim *interp</value></param>
<param><key>width</key><value>lpf_trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lpf_cutoff</value></param>
<param><key>label</key><value>LPF Cut Off</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>24e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lpf_trans</value></param>
<param><key>label</key><value>LPF Trans</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nfft</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>gui_hint</key><value>2,4,2,4</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
<param><key>gui_hint</key><value>7,4,1,4</value></param>
</block>
<block>
<key>pyqt_raster_plot</key>
<param><key>id</key><value>pyqt_raster_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,4,2,4</value></param>
<param><key>l</key><value></value></param>
<param><key>style</key><value>line</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>4,0,2,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>gui_hint</key><value>4,2,2,2</value></param>
<param><key>size</key><value>256</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate*interp/decim</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>5,4,2,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1_0</value></param>
<param><key>bw</key><value>samp_rate / decim*interp</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,0,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>pre-d</value></param>
<param><key>label2</key><value>agc_filt</value></param>
<param><key>name</key><value>"RX Spectrum"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-150</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>7,0,1,2</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>20000</value></param>
<param><key>min</key><value>-20000</value></param>
<param><key>update_time</key><value>0.0010</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>6,7,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>short</value></param>
<param><key>label1</key><value>Freq Offset</value></param>
<param><key>unit1</key><value>Hz</value></param>
<param><key>label2</key><value>Phase</value></param>
<param><key>max</key><value>32767</value></param>
<param><key>min</key><value>-32767</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>7,2,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate*interp/decim</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Error</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>2,0,2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>50000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.0</value></param>
<param><key>tr_tag</key><value>"burst"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>6,0,2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>50000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.0</value></param>
<param><key>tr_tag</key><value>"burst"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate / decim*interp</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,4,2,4</value></param>
<param><key>name</key><value>"RX Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>reduce to 48k sample rate</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>interp</key><value>interp</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>vcc_qt_hex_text</key>
<param><key>id</key><value>vcc_qt_hex_text_0</value></param>
<param><key>gui_hint</key><value>8,4,1,4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>soft_bits</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>burst</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>fft</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>agc_filt</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_0</value></param>
<param><key>stream_id</key><value>pred_48k</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_1</value></param>
<param><key>stream_id</key><value>trigger1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_1_0</value></param>
<param><key>stream_id</key><value>fsk_demod</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_2</value></param>
<param><key>stream_id</key><value>burst</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_2_0</value></param>
<param><key>stream_id</key><value>freq_correct</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>soft_bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>burst</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>fft</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>agc_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0</value></param>
<param><key>stream_id</key><value>agc_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_0</value></param>
<param><key>stream_id</key><value>trigger1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>trigger1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>agc_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_2</value></param>
<param><key>stream_id</key><value>freq_correct</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>virtual_sink_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>virtual_sink_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_burst_tagger_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_short_0</source_block_id><sink_block_id>blocks_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_1</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_2</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_number_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_abs_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_remove_0</source_block_id><sink_block_id>burst_length_detect_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>virtual_sink_2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_fsk_time_sync_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>pdus</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_length_detect_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_0</source_block_id><sink_block_id>pyqt_meta_text_output_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_1</source_block_id><sink_block_id>blocks_char_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>kiss_nrzi_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>virtual_sink_2_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>blocks_pdu_remove_0</sink_block_id><source_key>pdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>pyqt_time_plot_0</sink_block_id><source_key>pdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>pdus_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>kiss_pdu_to_kiss_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>kiss_nrzi_decode_0</source_block_id><sink_block_id>kiss_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_pdu_to_kiss_0</source_block_id><sink_block_id>vcc_qt_hex_text_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>virtual_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_skiphead_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_2</source_block_id><sink_block_id>analog_quadrature_demod_cf_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
