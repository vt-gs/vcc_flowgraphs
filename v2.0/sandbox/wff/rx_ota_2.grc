<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_ota_1200</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_filt_cutoff</value></param>
<param><key>value</key><value>24000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_filt_trans</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>250</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_2</value></param>
<param><key>value</key><value>2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_dev</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_2</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resamp_1</value></param>
<param><key>value</key><value>interp / decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resamp_2</value></param>
<param><key>value</key><value>interp_2 / decim_2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>416.513e6</value></param>
<param><key>gui_hint</key><value>main_tab@0:8,0,1,2</value></param>
<param><key>label</key><value>RX Freq</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>main_tab@0:8,2,1,2</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_offset</value></param>
<param><key>value</key><value>4.35e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>value</key><value>5*8</value></param>
<param><key>gui_hint</key><value>main_tab@2:4,0,10,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>30</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>10</value></param>
<param><key>comment</key><value>automatic gain control</value></param>
<param><key>decay_rate</key><value>1e-1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>65536</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1_0</value></param>
<param><key>comment</key><value>FSK/GMSK
demodulator</value></param>
<param><key>gain</key><value>quad_demod_gain</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_2</value></param>
<param><key>comment</key><value>Expects KISS Frames on input
Sends KISS Frames on output
&lt;FEND&gt;&lt;CMD&gt;&lt;DATA&gt;&lt;FEND&gt;
DATA = AX.25 Frame</value></param>
<param><key>host</key><value>0.0.0.0</value></param>
<param><key>mtu</key><value>1024</value></param>
<param><key>port</key><value>8000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>comment</key><value>soft bits to hard bits</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>comment</key><value>Timing Recovery</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.25</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samps_per_symb*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0</value></param>
<param><key>access_code</key><value>01111110</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>"flag"</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>comment</key><value>G3RUH Polynomial
1+x^12+x^17</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime as dt; import string; import math</value></param>
</block>
<block>
<key>kiss_hdlc_deframer</key>
<param><key>id</key><value>kiss_hdlc_deframer_0</value></param>
<param><key>check_fcs</key><value>True</value></param>
<param><key>comment</key><value>Searches for flags to detect Frame
'unstuffs' tx bit stuffing
checks FCS for bit errors</value></param>
<param><key>max_length</key><value>300</value></param>
</block>
<block>
<key>kiss_nrzi_decode</key>
<param><key>id</key><value>kiss_nrzi_decode_0</value></param>
<param><key>comment</key><value>NRZI Differential
Line Decoding</value></param>
</block>
<block>
<key>kiss_pdu_to_kiss</key>
<param><key>id</key><value>kiss_pdu_to_kiss_0</value></param>
<param><key>comment</key><value>Wraps AX.25 Frame in KISS protocol
&lt;FEND&gt;&lt;CMD&gt;&lt;DATA&gt;&lt;FEND&gt;
Escapes DATA bytes as needed</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>comment</key><value>Channel Filter
Wide enough for doppler spread</value></param>
<param><key>cutoff_freq</key><value>chan_filt_cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate / decim *interp</value></param>
<param><key>width</key><value>chan_filt_trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>comment</key><value>narrow signal filter</value></param>
<param><key>cutoff_freq</key><value>lpf_cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate / decim * interp /decim_2 * interp_2</value></param>
<param><key>width</key><value>lpf_trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lpf_cutoff</value></param>
<param><key>label</key><value>LPF Cutoff</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>7.2e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lpf_trans</value></param>
<param><key>label</key><value>LPF Trans Width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e3</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>main_tab</value></param>
<param><key>gui_hint</key><value>0,0,4,4</value></param>
<param><key>label0</key><value>Full Band</value></param>
<param><key>label1</key><value>RX Channel</value></param>
<param><key>label2</key><value>baseband</value></param>
<param><key>label3</key><value>Rate Detect</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>ax25</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim*interp</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@0:0,0,4,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/decim*interp</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@3:0,0,1,8</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-150</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate*interp/decim*interp_2/decim_2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@1:0,4,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>'orig'</value></param>
<param><key>label2</key><value>'corr'</value></param>
<param><key>name</key><value>"Burst RX Spectrum"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1_0</value></param>
<param><key>bw</key><value>samp_rate / decim*interp / decim_2 * interp_2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@1:0,0,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>pre-d</value></param>
<param><key>name</key><value>"Ceres Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-150</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>main_tab@2:0,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Soft Bits"</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate / 2 / decim * interp / samps_per_symb</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>main_tab@2:0,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Hard Bits"</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate /2/decim * interp / samps_per_symb</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>main_tab@2:1,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"NRZ-I Decode"</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate /2/decim * interp / samps_per_symb</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>main_tab@2:1,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>name</key><value>"Descrambled"</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate /2/decim * interp / samps_per_symb</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"flag"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>ymax</key><value>1.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decim*interp</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@0:4,0,4,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate / decim*interp / decim_2 * interp_2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>main_tab@1:2,0,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.0010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate/decim*interp</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>main_tab@3:1,0,1,8</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.010</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>quad_demod_gain</value></param>
<param><key>label</key><value>Quad Demod Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6.1</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(decim)</value></param>
<param><key>interp</key><value>int(interp)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_3</value></param>
<param><key>comment</key><value>reduce to 48k sample rate</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>MM Clk Rcvr Samps/Symb</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5.1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(rx_freq-rx_offset, samp_rate/2)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>vcc_qt_hex_text</key>
<param><key>id</key><value>vcc_qt_hex_text_tx_0</value></param>
<param><key>comment</key><value>rx ax.25 frames</value></param>
<param><key>gui_hint</key><value>main_tab@1:2,4,2,4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>hard_bits</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>agc_filt</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_rx_kiss</value></param>
<param><key>stream_id</key><value>rx_kiss</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_tx_kiss</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>tx_kiss</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>hard_bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>agc_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0</value></param>
<param><key>stream_id</key><value>agc_filt</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_rx_kiss</value></param>
<param><key>stream_id</key><value>rx_kiss</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_2</source_block_id><sink_block_id>virtual_sink_tx_kiss</sink_block_id><source_key>pdus</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>kiss_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>kiss_pdu_to_kiss_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>kiss_hdlc_deframer_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>kiss_nrzi_decode_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_nrzi_decode_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kiss_pdu_to_kiss_0</source_block_id><sink_block_id>vcc_qt_hex_text_tx_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>kiss_pdu_to_kiss_0</source_block_id><sink_block_id>virtual_sink_rx_kiss</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>qtgui_freq_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>kiss_nrzi_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>rational_resampler_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_rx_kiss</source_block_id><sink_block_id>blocks_socket_pdu_0_2</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
