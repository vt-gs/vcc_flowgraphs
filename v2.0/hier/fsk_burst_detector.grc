<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_burst_detector</value></param>
<param><key>category</key><value>[VCC Hier Blocks]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>FSK Burst Detector</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1</value></param>
<param><key>comment</key><value>FSK/GMSK
demodulator</value></param>
<param><key>gain</key><value>(samp_rate/decim*interp)/(2*math.pi*fsk_dev/8.0)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>avg_len</value></param>
<param><key>label</key><value>Avg Length</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100.0</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>cons_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>int(avg_len)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/avg_len</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cons_offset</value></param>
<param><key>label</key><value>Constant Offset</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>125</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fsk_dev</value></param>
<param><key>label</key><value>FSK Deviation</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10000.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interp</value></param>
<param><key>label</key><value>Interpolation</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>trigger</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
