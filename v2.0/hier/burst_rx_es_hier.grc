<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>burst_rx_es_hier</value></param>
<param><key>category</key><value>[VCC Hier Blocks]</value></param>
<param><key>description</key><value>Event Stream Based Burst Processor</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Burst RX Processor</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>avg_len</value></param>
<param><key>label</key><value>Avgerage Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baud</value></param>
<param><key>label</key><value>Symbol Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>blocks_pdu_remove</key>
<param><key>id</key><value>blocks_pdu_remove_0</value></param>
<param><key>k</key><value>pmt.intern("es::event_buffer")</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>est_len</value></param>
<param><key>minoutbuf</key><value>baud*samps_per_symb*2</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>est_len</value></param>
<param><key>minoutbuf</key><value>baud*samps_per_symb*2</value></param>
</block>
<block>
<key>burst_length_detect_c</key>
<param><key>id</key><value>burst_length_detect_c_0</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>int(samp_rate)</value></param>
<param><key>lookback</key><value>avg_len * 2</value></param>
<param><key>guard</key><value>300</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>thresh</key><value>trigger_thresh</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>burst_orig</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>burst_corr</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>brst_corr</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>meta</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>agc_filt</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>trig</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pdu_utils_extract_metadata</key>
<param><key>id</key><value>pdu_utils_extract_metadata_0</value></param>
<param><key>key</key><value>pmt.intern("cfo_est")</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>offset</key><value>0.0</value></param>
<param><key>scale</key><value>1.0</value></param>
</block>
<block>
<key>pdu_utils_extract_metadata</key>
<param><key>id</key><value>pdu_utils_extract_metadata_0_0</value></param>
<param><key>key</key><value>pmt.intern("snr")</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>offset</key><value>0.0</value></param>
<param><key>scale</key><value>1.0</value></param>
</block>
<block>
<key>pdu_utils_extract_metadata</key>
<param><key>id</key><value>pdu_utils_extract_metadata_0_0_0</value></param>
<param><key>key</key><value>pmt.intern("cfo_est")</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>offset</key><value>0.0</value></param>
<param><key>scale</key><value>1.0</value></param>
</block>
<block>
<key>pdu_utils_extract_metadata</key>
<param><key>id</key><value>pdu_utils_extract_metadata_0_0_0_0</value></param>
<param><key>key</key><value>pmt.intern("rx_freq")</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>offset</key><value>0.0</value></param>
<param><key>scale</key><value>1.0</value></param>
</block>
<block>
<key>pdu_utils_extract_metadata</key>
<param><key>id</key><value>pdu_utils_extract_metadata_0_0_1</value></param>
<param><key>key</key><value>pmt.intern("snr")</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>offset</key><value>0.0</value></param>
<param><key>scale</key><value>1.0</value></param>
</block>
<block>
<key>pdu_utils_extract_metadata</key>
<param><key>id</key><value>pdu_utils_extract_metadata_0_1</value></param>
<param><key>key</key><value>pmt.intern("datetime")</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>offset</key><value>0.0</value></param>
<param><key>scale</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_symb</value></param>
<param><key>label</key><value>Samps / Symb</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>trigger_thresh</value></param>
<param><key>label</key><value>Trigger Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-2</value></param>
</block>
<block>
<key>vcc_burst_cfo_est_gmsk</key>
<param><key>id</key><value>vcc_burst_cfo_est_gmsk_0</value></param>
<param><key>Fs</key><value>samp_rate</value></param>
</block>
<block>
<key>vcc_burst_snr</key>
<param><key>id</key><value>vcc_burst_snr_0</value></param>
<param><key>length</key><value>avg_len</value></param>
<param><key>sps</key><value>samps_per_symb</value></param>
</block>
<block>
<key>vcc_es_tag_to_utc</key>
<param><key>id</key><value>vcc_es_tag_to_utc_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>vcc_trigger_timestamp_pdu</key>
<param><key>id</key><value>vcc_trigger_timestamp_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>threshold</key><value>trigger_thresh</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>meta_ts</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_2_0</value></param>
<param><key>stream_id</key><value>burst_pdu</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>burst_pdu</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>meta_ts</value></param>
</block>
<connection><source_block_id>blocks_pdu_remove_0</source_block_id><sink_block_id>vcc_es_tag_to_utc_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>vcc_burst_snr_0</sink_block_id><source_key>cpdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>blocks_pdu_remove_0</sink_block_id><source_key>pdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>vcc_trigger_timestamp_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdu_utils_extract_metadata_0_0_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pdu_utils_extract_metadata_0_0_0_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pdu_utils_extract_metadata_0_0_1</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pdu_utils_extract_metadata_0_1</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>vcc_burst_cfo_est_gmsk_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>corrected</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>vcc_burst_cfo_est_gmsk_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>corrected</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>vcc_burst_cfo_est_gmsk_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>corrected</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>vcc_burst_cfo_est_gmsk_0</source_block_id><sink_block_id>pdu_utils_extract_metadata_0_0_0</sink_block_id><source_key>corrected</source_key><sink_key>dict</sink_key></connection>
<connection><source_block_id>vcc_burst_cfo_est_gmsk_0</source_block_id><sink_block_id>pdu_utils_extract_metadata_0_0_0_0</sink_block_id><source_key>corrected</source_key><sink_key>dict</sink_key></connection>
<connection><source_block_id>vcc_burst_cfo_est_gmsk_0</source_block_id><sink_block_id>pdu_utils_extract_metadata_0_0_1</sink_block_id><source_key>corrected</source_key><sink_key>dict</sink_key></connection>
<connection><source_block_id>vcc_burst_cfo_est_gmsk_0</source_block_id><sink_block_id>pdu_utils_extract_metadata_0_1</sink_block_id><source_key>corrected</source_key><sink_key>dict</sink_key></connection>
<connection><source_block_id>vcc_burst_cfo_est_gmsk_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>vcc_burst_snr_0</source_block_id><sink_block_id>vcc_burst_cfo_est_gmsk_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>vcc_es_tag_to_utc_0</source_block_id><sink_block_id>virtual_sink_2_2_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>vcc_trigger_timestamp_pdu_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>ts</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>burst_length_detect_c_0</sink_block_id><source_key>out</source_key><sink_key>cpdus</sink_key></connection>
</flow_graph>
